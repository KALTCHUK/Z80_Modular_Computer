# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C4051 Microchip
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: clock +hex
  AfterMake: srec_cat #H -Intel -o $H@P.bin -Binary
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: clock.c
