# Keil uVision project i2c_manager.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C4051 Microchip
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: i2c_manager
  c flags: Optimize=8 SizeSpeed=1
