# Keil uVision project square wave.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C4051 Microchip
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: square wave +hex
  AfterMake: srec_cat #H -Intel -fill 0xFF 0x0000 0x0800 -o $H@P.bin -Binary
  c flags: Optimize=8
  group Source Group 1
    ./: sw10.c
