# Keil uVision project serial_comm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C4051 Microchip
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: serial_comm
  c flags: Optimize=8 SizeSpeed=1
