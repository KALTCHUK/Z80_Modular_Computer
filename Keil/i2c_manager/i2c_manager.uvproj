# Keil uVision project i2c_manager.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C4051 Microchip
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: i2c_manager +hex
  AfterMake: srec_cat #H -Intel -Fill 0xff 0x0000 0x07ff -o $H@P.bin -Binary
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: i2c_manager.c
  group New header group
    ./: i2c_manager_2.c
